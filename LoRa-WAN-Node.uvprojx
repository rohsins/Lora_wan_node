# Keil uVision project LoRa-WAN-Node.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: EFM32GG980F1024 Silicon Labs
  pack: SiliconLabs.EFM32GG_DFP.5.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRa-WAN-Node
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EFM32GG980F1024
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: Main.cpp main.c RingBuffer.cpp LoRa.cpp lis3dsh.cpp rn2483.cpp
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS:Keil RTX 4.81.1, Device:emlib:CMU 5.3.5, Device:emlib:EMU 5.3.5, Device:emlib:Framework 5.3.5, Device:emlib:GPIO 5.3.5, Device:emlib:SYSTEM 5.3.5, Device:emlib:USART 5.3.5, Device:Startup 5.7.0
